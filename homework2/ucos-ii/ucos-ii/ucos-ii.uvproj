# Keil uVision project ucos-ii.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos-ii
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c system_stm32f4xx.c os.h os_cfg.h os_cpu.h ucos_ii.h os_cpu_a.asm main.c GLCD_16bitIF_STM32F4xx.c I2C_STM32F4xx.c JOY.c
    ../../pong_samplesolution/: pong.c
    ../../tetris_samplesolution/tetris/: tetris.c
